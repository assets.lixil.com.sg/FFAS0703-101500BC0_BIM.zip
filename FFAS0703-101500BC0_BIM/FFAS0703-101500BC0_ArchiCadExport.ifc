Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-03-30T09:26:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190731_1515(x64) - Exporter 20.1.1.1 - Alternate UI 20.1.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 30 09:26:09 2023 * Host: L0310_2208R689 * Database: C:\Users\phitssat\AppData\Local\Temp\bb6f013f-03b1-4947-96b7-5025e4dcd981\4ab78460-b568-408d-a6a0-d1c1aec3e6a6\ifc * Database version: 5507 * Database creation date: Thu Mar 30 09:26:08 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 30 09:26:09 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 30 09:26:09 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort, Port_346501
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: FFAS0703-101500BC0_REVIT:Neo Modern SH SL Vessel Faucet (Chr, FFAS0703-101500BC0_REVIT:Neo Modern SH SL Vessel Faucet (Chr:346501
In: Level 1
Classification: G3010 Water Supply (Uniformat); Material: Steel, Chrome Plated
Pset_DistributionFlowElementCommon - Reference: Neo Modern SH SL Vessel Faucet (Chr; sets with these values: 2
Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Pset_ProductRequirements - Category: Plumbing Fixtures
